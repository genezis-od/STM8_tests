<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM8_PVD_instead_ADC.ewp</path>
  </project>
  <batchBuild/>
</workspace>


